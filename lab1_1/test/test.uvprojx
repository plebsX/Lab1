# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKW41Z256xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: IRAM(0x1FFF8000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --show_cmdline --depend=filename
  c include: .\blinky;.\board;.\FreeRTOS;.\board
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  link misc: --map
  group Blinky
    ./blinky/: Blinky.c
  group board
    ./board/: system_MKW41Z4.c system_MKW41Z4.s
  group FreeRTOS
    ./FreeRTOS/: list.c port.c queue.c tasks.c timers.c heap_1.c fsl_tickless_systick.c
